# Keil uVision project uIP0.9.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89x516RD2 SST
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0xFFFF) CLOCK(40000000)
  output: 15uIP +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c uip.c uip_arch.c uip_arp.c uipopt.h spi.c enc28j60.c tcp_server.c example0.c USART.c
